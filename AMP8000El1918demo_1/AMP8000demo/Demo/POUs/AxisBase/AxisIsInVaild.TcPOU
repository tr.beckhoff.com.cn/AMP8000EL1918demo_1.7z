FUNCTION AxisIsInVaild : BOOL
VAR_INPUT
	nAxisId				:	UINT;
END_VAR
VAR
END_VAR

AxisIsInVaild := nAxisId <= cMaxAxis AND nAxisId >= cMinAxis;

END_FUNCTION
